Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2016-06-24T13:56:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 24 13:56:54 2016 * Host: B3ROBRAWR3020 * Database: C:\Users\CR\AppData\Local\Temp\{80383079-2015-4FF1-AE89-2C05F5B228DE}\ifc * Database version: 5507 * Database creation date: Fri Jun 24 13:56:54 2016 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jun 24 13:56:54 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 24 13:56:54 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\Brink IFC\Full\Finale\VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right_400_4-0 R.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcAirToAirHeatRecovery: 400_4-0 R, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right:400_4-0 R:24642
In: Level 1
Type - Material: Color RGB 062-062-062, Color RAL 9016, Color RGB 162-162-162
Type - Dimensions - Connection Diameter: 180 mm; Depth: 564 mm; Height: 765 mm; Length: 677 mm
Type - Electrical - Loads - Nominal Voltage: 230 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: 400_4-0 R; Content Supplier URL: www.mepcontent.eu; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 2.0; ETIM Article Class: EC011285; Family Version: 10.14; GTIN: 8718391055388; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 420020; Manufacturer URL: www.brinkclimatesystems.nl/downloads_renovent-excellent-300-400; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: 400_3-1 RP+; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2015; Type Name: 400_4-0 R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Glass: Color RGB 218-227-224; Grey: Color RGB 062-062-062; Light Grey: Color RGB 162-162-162; White: Color RAL 9016
Type - Other - Category: Mechanical Equipment; Angle 1: 90 deg; Angle 2: 90 deg; Connection Inner Radius: 87 mm; Connection Radius: 89 mm; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right; Flange Radius: 100 mm
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 3.26638 m2; Volume: 0.286979 m3
Electrical - Loads - Apparent Power: 0 W; Nomial Current: 0 A
Identity Data - Mark: 1
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Sanitary,Supply Air,Return Air,Exhaust Air,Supply Air,Power
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Return Air Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right: 400_4-0 R; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right: 400_4-0 R; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right: 400_4-0 R; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_400 Right: 400_4-0 R; Wall Offset: 10 mm
Phasing - Phase Created: New Construction
Visibility - Mounting Strip: yes; Service Area: no
