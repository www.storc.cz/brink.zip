Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2016-12-05T12:56:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20151007_1515(x64) - Exporter 15.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 05 12:56:04 2016 * Host: B3ROBRAWR3325 * Database: C:\Users\DDA\AppData\Local\Temp\{7198A9DA-37BE-4577-975B-A6350AC23EB9}\ifc * Database version: 5507 * Database creation date: Mon Dec 05 12:56:02 2016 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 05 12:56:03 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 05 12:56:03 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcAirToAirHeatRecovery: Renovent Sky 200 Plus, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN:Renovent Sky 200 Plus:899796
In: Level 1
Type - Material: Color RGB 062-062-062, Color RGB 246-246-246, Color RGB 036-036-036, Color RGB 144-144-144
Type - Dimensions - Height: 198 mm; Length: 1000 mm; Width: 660 mm
Type - Electrical - Loads - Nominal Voltage: 230.002 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: Renovent Sky 200 Plus; Content Supplier URL: www.mepcontent.eu; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 3.0; ETIM Article Class: EC011285; Family Version: 10.23; GTIN: 08718391192816; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 424001; Manufacturer URL: http://www.brinkclimatesystems.nl/getattachment/2d9bccc3-62b9-4b45-ab44-7a68c4ae98f2; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: Renovent Sky 200 Plus; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2015; Type Name: Renovent Sky 200 Plus; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 036-036-036; Grey 1: Color RGB 062-062-062; Grey 2: Color RGB 144-144-144; Service Area: Color RGB 218-227-224; White: Color RGB 246-246-246
Type - Other - Category: Mechanical Equipment; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 2.97282 m2; Volume: 0.137407 m3
Electrical - Loads - Apparent Load: 0 W; Nominal Current: 0 A
Identity Data - Mark: 1
Mechanical - Air Flow Rate: 0; Drain Fixture Units: 0; Heating Power: 0; Nominal Flow Rate: 0; System Classification: Power,Sanitary,Supply Air,Exhaust Air,Supply Air,Return Air
Mechanical - Flow - Deflate Flow: 0 m3/s; Fresh Air Flow: 0 m3/s; Return Flow: 0 m3/s; Supply Flow: 0 m3/s
Other - Angle Condition: 90 deg; Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN: Renovent Sky 200 Plus; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN: Renovent Sky 200 Plus; Service Area Bottom: 0 mm; Service Area Height: 208 mm; Service Area Top: 0 mm; Service Area Width: 660 mm; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN: Renovent Sky 200 Plus; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_200_NL-EN: Renovent Sky 200 Plus
Phasing - Phase Created: New Construction
Visibility - Ceiling Mounted: no; Mounting Service Area: no; Show Service Area: no; Wall Mounted: yes
